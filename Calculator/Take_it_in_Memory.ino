void take_it_in_memory() {
if (sTop == 1)
    goto lineN;

  if (a[0] == -1) {
    a[0] = a2[0] = a3[0] = a4[0] = a9[0] = a10[0] = a11[0] = a12[0] = 0;
    a5[0] = a6[0] = a7[0] = a8[0] = a13[0] = a14[0] = a15[0] = a16[0] = 1;
  }
  else
    a2[0] = a3[0] = a4[0] = a5[0] = a6[0] = a7[0] = a8[0] =  a9[0] = a10[0] = a11[0] = a12[0] = a13[0] = a14[0] = a15[0] = a16[0] = a[0];

  if (a[1] == -1) {
    a[1] = a2[1] = a5[1] = a6[1] = a9[1] = a10[1] = a13[1] = a14[1] = 0;
    a3[1] = a4[1] = a7[1] = a8[1] = a11[1] = a12[1] = a15[1] = a16[1] = 1;
  }
  else
    a2[1] = a3[1] = a4[1] = a5[1] = a6[1] = a7[1] = a8[1] =  a9[1] = a10[1] = a11[1] = a12[1] = a13[1] = a14[1] = a15[1] = a16[1] = a[1];

  if (a[2] == -1) {
    a[2] = a3[2] = a5[2] = a7[2] = a9[2] = a11[2] = a13[2] = a15[2] = 0;
    a2[2] = a4[2] = a6[2] = a8[2] = a10[2] = a12[2] = a14[2] = a16[2] = 1;
  }
  else
    a2[2] = a3[2] = a4[2] = a5[2] = a6[2] = a7[2] = a8[2] = a9[2] = a10[2] = a11[2] = a12[2] = a13[2] = a14[2] = a15[2] = a16[2] = a[2];

  if (a[3] == -1) {
    a[3] = a2[3] = a3[3] = a4[3] = a5[3] = a6[3] = a7[3] = a8[3]  = 0;
    a9[3] = a10[3] = a11[3] = a12[3] = a13[3] = a14[3] = a15[3] = a16[3] = 1;
  }
  else
    a2[3] = a3[3] = a4[3] = a5[3] = a6[3] = a7[3] = a8[3] =  a9[3] = a10[3] = a11[3] = a12[3] = a13[3] = a14[3] = a15[3] = a16[3] = a[3];

  c = a[3] * 8 + a[0] * 4 + a[1] * 2 + a[2];
  if( c < 16){  
  b[c] = 1;
  c = a2[3] * 8 + a2[0] * 4 + a2[1] * 2 + a2[2];
  b[c] = 1;
  c = a3[3] * 8 + a3[0] * 4 + a3[1] * 2 + a3[2];
  b[c] = 1;
  c = a4[3] * 8 + a4[0] * 4 + a4[1] * 2 + a4[2];
  b[c] = 1;
  c = a5[3] * 8 + a5[0] * 4 + a5[1] * 2 + a5[2];
  b[c] = 1;
  c = a6[3] * 8 + a6[0] * 4 + a6[1] * 2 + a6[2];
  b[c] = 1;
  c = a7[3] * 8 + a7[0] * 4 + a7[1] * 2 + a7[2];
  b[c] = 1;
  c = a8[3] * 8 + a8[0] * 4 + a8[1] * 2 + a8[2];
  b[c] = 1;
  c = a9[3] * 8 + a9[0] * 4 + a9[1] * 2 + a9[2];
  b[c] = 1;
  c = a10[3] * 8 + a10[0] * 4 + a10[1] * 2 + a10[2];
  b[c] = 1;
  c = a11[3] * 8 + a11[0] * 4 + a11[1] * 2 + a11[2];
  b[c] = 1;
  c = a12[3] * 8 + a12[0] * 4 + a12[1] * 2 + a12[2];
  b[c] = 1;
  c = a13[3] * 8 + a13[0] * 4 + a13[1] * 2 + a13[2];
  b[c] = 1;
  c = a14[3] * 8 + a14[0] * 4 + a14[1] * 2 + a14[2];
  b[c] = 1;
  c = a15[3] * 8 + a15[0] * 4 + a15[1] * 2 + a15[2];
  b[c] = 1;
  c = a16[3] * 8 + a16[0] * 4 + a16[1] * 2 + a16[2];
  b[c] = 1;
  }
lineN:  
  if ( b_opening == 0) {
    a[3] = a[2] = a[1] = a[0] = -1;
    c = 0;
    sTop = 0;
    pp = 0;
    flag = 0;
    flag_x = 0;
    flag_y = 0;
    flag_z = 0;
    flag_w = 0;
    flagp =0;
    flagpn = 0;
    ghorar_dim = 0;
    ay = 0;
  }

  if( b_opening != 0){
    a[3] = d[3];
    a[2] = d[2];
    a[1] = d[1];
    a[0] = d[0];
    sTop = sTop2;
    pp = pp2;
    flag = flag2;
    flag_x = flag_x2;
    flag_y = flag_y2;
    flag_z = flag_z2;
    flag_w = flag_w2 ;
    flagp = flagp2 ;
    flagpn2=flagpn2;
    ghorar_dim = ghorar_dim2;
    ay = 0;
    
  }
}
